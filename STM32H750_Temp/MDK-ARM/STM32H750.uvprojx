# Keil uVision project STM32H750.uvprojx, settings and files
target STM32H750 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H750 +hex
  AfterMake: CopyAndReplace.bat
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Objects\@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;..\Drivers\Include;..\Drivers\CMSIS;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM7\r0p1;..\FreeRTOS\port\MemMang;..\FreeRTOS;..\User;..\Software;..\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group User
    ../User/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/Core
    ../Drivers/Core/: startup_stm32h743xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/: system_stm32h7xx.c
  group Drivers/HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_wwdg.c
  group Software_App
    ../Software/: app_debug.c app_task_entry.c
  group Hardware_Driver
    ../Hardware/: driver_gpio.c driver_sysclk.c
  group FreeRTOS
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/port/RVDS/ARM_CM7/r0p1/: port.c
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/: FreeRTOSConfig.h
software components: CMSIS:CORE 4.3.0
